# Autodesk Inventor assembly: 22.1096 SLIDE RAIL LN-S
## iProperties
Created: 2007-06
Part Number: 22.1096 SLIDE RAIL LN-S
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
